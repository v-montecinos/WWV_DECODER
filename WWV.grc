options:
  parameters:
    author: vhmg
    generate_options: qt_gui
    id: TEST_WWW_DECODER
    output_language: python
    title: WWV TIME SIGNAL DECODER
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '48'
  states: {}
- name: decoded
  id: variable_qtgui_label
  parameters:
    label: Decoded Time
    type: string
    value: time_year
  states: {}
- name: prob1
  id: variable_function_probe
  parameters:
    block_id: probSign1
    function_name: level
    poll_rate: '50'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: time_year
  id: variable
  parameters:
    value: python_mod.www_decoder(prob1)
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '50'
    max_gain: '200'
    rate: '1e-5'
    reference: '1.0'
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: HDMI
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: BlackHole 2ch
    samp_rate: '48000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1.5'
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-100'
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass_2(1,samp_rate,100,10,50)
    type: fcf
  states: {}
- name: probSign1
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: python_mod
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\n\nimport sys\nimport time\n\n\nt_start     = 0     # Rising edge timer\nt_stop      = 0     # Falling edge timer\nflag        = 0     # Flag\ndetected    = 0     # Mark pulse detected flag\nmark_t      = 0     # Duration of mark\nspace_t     = 0     # Duration of space\nsync        = 0     # Sync condition flag\nerror       = 1     # Error flag\nbit_val     = 1     # 0 for 0, 1 for 1 & 2 for Position identifiers\ncounter     = 1     # Pulse counter\n\nminutes     = 0\nhours       = 0\nunit_year   = 0\nten_year    = 0\n\nyear        = 0\n\noutput_str  = \"\"\n\n\ndef www_decoder(prob_level):\n    global t_start,t_stop,flag,detected,mark_t,space_t,sync,error,bit_val,counter,minutes,hours,unit_year,ten_year,year\n    global output_str\n\n#**********************************************************************************************************************\n# Wait until the \"Hole\" condition is detected (1000 ms of silence) if occur the sync flag is True\n#**********************************************************************************************************************\n\n    if (sync == 0):\n    \n            if (prob_level == 0 and flag == 0):                     # Detect the falling edge and get the current time\n                    flag = 1\n                    t_start = time.time()\n                    \n            if (prob_level == 1 and flag == 1):                     # Detect the rising edge and get the current time\n                    flag = 0\n                    t_stop = time.time()\n                    detected = 1\n            \n            if (detected == 1):                                     # If a whole pulse occur calc the pulse duration\n                    space_t = round(t_stop - t_start, 3)*1000       # Space duration in ms\n                    detected = 0\n                    print (space_t)\n                    \n                    if (space_t in range(1150,1250)):               # Range detection for \"Hole\" (1200 ms)\n                        print (\"\\n\")\n                        print (\"Start Sync condition detected\\n\")\n                        sync = 1\n                        \n#**********************************************************************************************************************\n# If sync flag is True,  wait until a whole pulse occur and calc the pulse duration and change detected to True\n#**********************************************************************************************************************\n\n    if (sync == 1):\n    \n            if (prob_level == 1 and flag == 0):                     # Detect the rising edge and get the current time\n                 flag = 1\n                 t_start = time.time()\n                 \n            if (prob_level == 0 and flag == 1):                     # Detect the falling edge and get the current time\n                 flag = 0\n                 t_stop = time.time()\n                 detected = 1\n                 \n#**********************************************************************************************************************\n# If detected is True, evaluate range detection for 0, 1 o Px\n#**********************************************************************************************************************\n\n    if (detected == 1):\n    \n                mark_t = round(t_stop - t_start, 3)*1000            # Pulse duration in ms\n                print (mark_t)\n                detected = 0\n                error = 1\n                        \n                if (mark_t in range(150,250)):                      # Range detection for os (200ms)\n                    bit_val = 0\n                    error   = 0\n\n                elif (mark_t in range(450,550)):                    # Range detection for 1s (500ms)\n                    bit_val = 1\n                    error   = 0\n\n                elif (mark_t in range(750,850)):                    # Range detection for Px (800ms)\n                    bit_val = 2\n                    error   = 0\n\n#**********************************************************************************************************************\n# If no error during the range detection continue with the decoding if not wait until de next sync condition\n#**********************************************************************************************************************\n                if (error == 1):\n                    sync = 0\n                    print (\"Range detection error!, waiting until the next sync\\n\")\n  \n                if (error == 0):\n                    counter = counter + 1\n  \n#**********************************************************************************************************************\n# BCD decode for the moment only hours, minutes and year\n#**********************************************************************************************************************\n\n                    if (counter == 5):\n                        unit_year = unit_year +  1 * bit_val        # Decode units of year\n                    elif (counter == 6):\n                        unit_year = unit_year +  2 * bit_val\n                    elif (counter == 7):\n                        unit_year = unit_year +  4 * bit_val\n                    elif (counter == 8):\n                        unit_year = unit_year +  8 * bit_val\n                        \n\n                    elif (counter == 11):                           # Decode minutes\n                        minutes = minutes +  1 * bit_val\n                    elif (counter == 12):\n                        minutes = minutes +  2 * bit_val\n                    elif (counter == 13):\n                        minutes = minutes +  4 * bit_val\n                    elif (counter == 14):\n                        minutes = minutes +  8 * bit_val\n                    elif (counter == 15):\n                        pass\n                    elif (counter == 16):\n                        minutes = minutes +  10 * bit_val\n                    elif (counter == 17):\n                        minutes = minutes +  20 * bit_val\n                    elif (counter == 18):\n                        minutes = minutes +  40 * bit_val\n                        \n                    elif (counter == 21):                           # Decode hours\n                        hours = hours +  1 * bit_val\n                    elif (counter == 22):\n                        hours = hours +  2 * bit_val\n                    elif (counter == 23):\n                        hours = hours +  4 * bit_val\n                    elif (counter == 24):\n                        hours = hours +  8 * bit_val\n                    elif (counter == 25):\n                        pass\n                    elif (counter == 26):\n                        hours = hours +  10 * bit_val\n                    elif (counter == 27):\n                        hours = hours +  20 * bit_val\n                        \n\n                    elif (counter == 52):                           # Decode tens of year\n                        ten_year = ten_year +  10 * bit_val\n                    elif (counter == 53):\n                        ten_year = ten_year +  20 * bit_val\n                    elif (counter == 54):\n                        ten_year = ten_year +  40 * bit_val\n                    elif (counter == 55):\n                        ten_year = ten_year +  80 * bit_val\n\n\n                    elif (counter == 59):\n                    \n#**********************************************************************************************************************\n# Data formating and extra validate\n#**********************************************************************************************************************\n                    \n                        hours = hours\n                        \n                        minutes = minutes + 1                       # Remenber add 1 minute because the decode finish\n                                                                    # before the next decode\n                        if (minutes == 60):\n                            minutes = 0\n                            hours = hours +1\n                            if (hours == 24):\n                                hours = 0\n                        \n                        year = 2000 + ten_year + unit_year\n                        \n                        error = 1\n                        if (minutes in range (0,59)):\n                            error = 0\n                        \n                        if (hours in range (0,23)):\n                            error = 0\n                             \n                        if (error == 1):\n                            print (\"Error decoding, waiting until the next sync\\n\")\n                            sync = 0\n                       \n                            \n                        print (\"Time: \",hours,\":\",minutes,\"UTC\",  \"Year:\",year)\n                        \n                        output_str = str(hours) + \":\" + str(minutes) + \"  UTC     \" + \"  Year:\" + str(year)\n                        \n#**********************************************************************************************************************\n# Reset counter and data before the next sync condition\n#**********************************************************************************************************************\n    \n                        sync      = 0\n                        counter   = 1\n                        minutes   = 0\n                        hours     = 0\n                        unit_year = 0\n                        ten_year  = 0\n                        year      = 0\n\n            \n    return output_str\n    \n"
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 0,1,1,6
    name: '"Signal Scope"'
    nconnections: '3'
    size: int(samp_rate/decimation*2)
    srate: samp_rate/decimation
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.001'
    decim: '1'
    gain: '1'
    ntaps: '16'
    samp_rate: samp_rate/decimation
    sym_rate: '1'
    type: fir_filter_fff
  states: {}

connections:
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0, '0']
- [analog_agc_xx_0, '0', root_raised_cosine_filter_0, '0']
- [audio_source_0, '0', audio_sink_0, '0']
- [audio_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_add_const_vxx_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_complex_to_mag_0, '0', analog_agc_xx_0, '0']
- [blocks_uchar_to_float_0, '0', probSign1, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '2']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_add_const_vxx_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
