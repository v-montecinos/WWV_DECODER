options:
  parameters:
    author: vhmg
    copyright: 2024 Vicente Montecinos
    generate_options: qt_gui
    id: WWV_TIME_DECODER
    output_language: python
    title: WWV TIME SIGNAL DECODER
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '48'
  states: {}
- name: decoded
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,0,1,2
    label: 'Decoded Time / Date:'
    type: string
    value: time_date
  states: {}
- name: filter_taps
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Filter
    rangeType: int
    start: '1'
    step: '1'
    stop: '64'
    value: '64'
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    label: WWV Frequency
    labels: '["2.5 MHz","5 MHz","10 MHz","15 MHz", "20 MHz","25 MHz"]'
    num_opts: '0'
    options: '[2500, 5000, 10000, 15000, 20000, 25000]'
    type: raw
    value: '20000'
  states: {state: disabled}
- name: offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: Offset
    start: '0'
    step: '0.01'
    stop: '3'
    value: '1'
  states: {}
- name: prob1
  id: variable_function_probe
  parameters:
    block_id: probSign1
    function_name: level
    poll_rate: '50'
    value: '0'
  states: {}
- name: rtl_sampling
  id: variable
  parameters:
    value: 2.304e6
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: time_date
  id: variable
  parameters:
    value: python_mod.www_decoder(prob1)
  states: {}
- name: upconverter
  id: variable
  parameters:
    value: 100e3
  states: {state: disabled}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '2e-3'
    reference: '1'
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: HDMI
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    device_name: HDMI
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: BlackHole 2ch
    samp_rate: '48000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-offset'
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-100'
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass_2(1,samp_rate,110,5,50)
    type: fcc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e3
    decim: '1'
    gain: '10'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.2e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: probSign1
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: python_mod
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\n\nimport sys\nimport time\nfrom datetime import datetime, timedelta, date\n\n\n\nt_start     = 0     # Rising edge timer\nt_stop      = 0     # Falling edge timer\nflag        = 0     # Flag\ndetected    = 0     # Mark pulse detected flag\nmark_t      = 0     # Duration of mark\nspace_t     = 0     # Duration of space\nsync        = 0     # Sync condition flag\nerror       = 1     # Error flag\nbit_val     = 1     # 0 for 0, 1 for 1 & 2 for Position identifiers\ncounter     = 1     # Pulse counter\n\nminutes     = 0\nhours       = 0\ndays        = 0\nunit_year   = 0\nten_year    = 0\n\nyear        = 0\n\noutput_str  = \"No time signal decoded yet!\"\n\n\ndef www_decoder(prob_level):\n    global t_start,t_stop,flag,detected,mark_t,space_t,sync,error,bit_val,counter,minutes,hours,unit_year,ten_year,year,days,output_str,res, res_date\n\n#**********************************************************************************************************************\n# Wait until the \"Hole\" or preamble condition is detected (1200 ms of silence) if occur the sync flag is True\n#**********************************************************************************************************************\n\n    if (sync == 0):\n    \n            if (prob_level == 0 and flag == 0):                     # Detect the falling edge and get the current time\n                    flag = 1\n                    t_start = time.time()\n                    \n            if (prob_level == 1 and flag == 1):                     # Detect the rising edge and get the current time\n                    flag = 0\n                    t_stop = time.time()\n                    detected = 1\n            \n            if (detected == 1):                                     # If a whole pulse occur calc the pulse duration\n                    space_t = round(t_stop - t_start, 3)*1000       # Space duration in ms\n                    detected = 0\n                    #print (\"space t:\",space_t,\" ms\")               # for debug porpuse\n                    \n                    if (space_t in range(1100,1300)):               # Range detection for \"Hole\" (1200 ms)\n                        print (\"\\n\")\n                        print (\"Start Sync condition detected\\n\")\n                        sync = 1\n                        \n#**********************************************************************************************************************\n# If sync flag is True,  wait until a whole pulse occur and calc the pulse duration and change detected to True\n#**********************************************************************************************************************\n\n    if (sync == 1):\n    \n            if (prob_level == 1 and flag == 0):                     # Detect the rising edge and get the current time\n                 flag = 1\n                 t_start = time.time()\n                 \n            if (prob_level == 0 and flag == 1):                     # Detect the falling edge and get the current time\n                 flag = 0\n                 t_stop = time.time()\n                 detected = 1\n                 \n#**********************************************************************************************************************\n# If detected is True, evaluate range detection for 0, 1 o Px\n#**********************************************************************************************************************\n\n    if (detected == 1):\n    \n                mark_t = round(t_stop - t_start, 3)*1000            # Pulse duration in ms\n                #print (\"mark t:\",mark_t,\" ms\")                     # for debug porpuse\n                detected = 0\n                error = 1\n                        \n                if (mark_t in range(150,250)):                      # Range detection for os (200ms)\n                    bit_val = 0\n                    error   = 0\n\n                if (mark_t in range(450,550)):                      # Range detection for 1s (500ms)\n                    bit_val = 1\n                    error   = 0\n\n                if (mark_t in range(750,850)):                      # Range detection for Px (800ms)\n                    bit_val = 2\n                    error   = 0\n\n#**********************************************************************************************************************\n# If no error during the range detection continue with the decoding if not wait until de next sync condition\n#**********************************************************************************************************************\n\n                if (error == 1):\n                    sync = 0\n                    print (\"Range detection error!, waiting until the next sync\\n\")\n                    \n  #**********************************************************************************************************************\n  # BCD decode for the moment only hours, minutes and year\n  #**********************************************************************************************************************\n                else:\n                    counter = counter + 1\n\n                    if (counter == 5):\n                        unit_year = unit_year +  1 * bit_val        # Decode units of year\n                    elif (counter == 6):\n                        unit_year = unit_year +  2 * bit_val\n                    elif (counter == 7):\n                        unit_year = unit_year +  4 * bit_val\n                    elif (counter == 8):\n                        unit_year = unit_year +  8 * bit_val\n                        \n\n                    elif (counter == 11):                           # Decode minutes\n                        minutes = minutes +  1 * bit_val\n                    elif (counter == 12):\n                        minutes = minutes +  2 * bit_val\n                    elif (counter == 13):\n                        minutes = minutes +  4 * bit_val\n                    elif (counter == 14):\n                        minutes = minutes +  8 * bit_val\n                    elif (counter == 16):\n                        minutes = minutes +  10 * bit_val\n                    elif (counter == 17):\n                        minutes = minutes +  20 * bit_val\n                    elif (counter == 18):\n                        minutes = minutes +  40 * bit_val\n                        \n                    elif (counter == 21):                           # Decode hours\n                        hours = hours +  1 * bit_val\n                    elif (counter == 22):\n                        hours = hours +  2 * bit_val\n                    elif (counter == 23):\n                        hours = hours +  4 * bit_val\n                    elif (counter == 24):\n                        hours = hours +  8 * bit_val\n                    elif (counter == 26):\n                        hours = hours +  10 * bit_val\n                    elif (counter == 27):\n                        hours = hours +  20 * bit_val\n                        \n                    elif (counter == 31):                           # Decode days\n                        days = days +  1 * bit_val\n                    elif (counter == 32):\n                        days = days +  2 * bit_val\n                    elif (counter == 33):\n                        days = days +  4 * bit_val\n                    elif (counter == 34):\n                        days = days +  8 * bit_val\n                    elif (counter == 36):\n                        days = days +  10 * bit_val                       \n                    elif (counter == 37):\n                        days = days +  20 * bit_val\n                    elif (counter == 38):\n                        days = days +  40 * bit_val    \n                    elif (counter == 39):\n                        days = days +  80 * bit_val\n                    elif (counter == 41):\n                        days = days +  100 * bit_val                            \n                    elif (counter == 42):\n                        days = days +  200 * bit_val                               \n                        \n                        \n                                            \n                        \n\n                    elif (counter == 52):                           # Decode tens of year\n                        ten_year = ten_year +  10 * bit_val\n                    elif (counter == 53):\n                        ten_year = ten_year +  20 * bit_val\n                    elif (counter == 54):\n                        ten_year = ten_year +  40 * bit_val\n                    elif (counter == 55):\n                        ten_year = ten_year +  80 * bit_val\n                        \n#**********************************************************************************************************************\n# Data formating and extra validate\n#**********************************************************************************************************************\n                    \n                    elif (counter == 60):\n                        minutes = minutes + 1                       # Remenber add 1 minute because the decode finish\n                                                                    # before the next decode\n                        if (minutes == 60):\n                            minutes = 0\n                            hours = hours +1\n                        if (hours == 24):\n                            hours = 0\n                        \n                        year = 2000 + ten_year + unit_year\n                                        \n                        \n                        if (minutes in range (0,59) and hours in range (0,23)):\n                            \n                            res_date = date(year, 1, 1) + timedelta(days=days - 1)          #calculate the diference between 1-1-year\n                        \n                            res = res_date.strftime(\"%m-%d-%Y\")\n                        \n                        \n                            output_str = str(hours) + \":\" + str(minutes) + \"  UTC     \" + str(res)\n                        \n                            print (output_str)\n                            \n                             \n                        else:\n                            print (\"Error decoding, waiting until the next sync\\n\")\n                            sync = 0\n                            \n\n\n#**********************************************************************************************************************\n# Reset counter and data before the next sync condition\n#**********************************************************************************************************************\n                        sync      = 0\n                        counter   = 1\n                        minutes   = 0\n                        hours     = 0\n                        days      = 0\n                        unit_year = 0\n                        ten_year  = 0\n                        year      = 0\n                        \n                        \n\n            \n    return output_str\n    \n"
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: rtl_sampling/decimation
    color1: '"green"'
    fc: (freq)*1e3
    fftsize: '1024'
    grid: 'True'
    type: complex
    width1: '2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 0,3,4,6
    label1: Before RRCF
    label2: After RRCF
    label3: Binary
    name: '"Signal Scope"'
    nconnections: '3'
    size: int(samp_rate/decimation*3)
    srate: samp_rate/decimation
    type: float
    width3: '2'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decimation
    interp: '1'
    type: ccc
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.001'
    decim: '1'
    gain: '1'
    ntaps: filter_taps
    samp_rate: samp_rate/decimation
    sym_rate: '4'
    type: fir_filter_fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '0'
    corr0: '-6'
    dc_offset_mode0: '1'
    freq0: (upconverter+freq)*1e3
    gain0: '70'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: rtl_sampling
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0, '0']
- [analog_agc_xx_0, '0', root_raised_cosine_filter_0, '0']
- [audio_source_0, '0', audio_sink_0, '0']
- [audio_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_add_const_vxx_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_mag_0, '0', analog_agc_xx_0, '0']
- [blocks_complex_to_mag_0_0, '0', audio_sink_0_0, '0']
- [blocks_uchar_to_float_0, '0', probSign1, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '2']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0_0, '0']
- [low_pass_filter_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_add_const_vxx_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
